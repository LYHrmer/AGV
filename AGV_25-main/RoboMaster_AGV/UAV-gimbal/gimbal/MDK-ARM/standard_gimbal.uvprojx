# Keil uVision project standard_gimbal.uvprojx, settings and files
target standard_gimbal (6140001::V6.14.1::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: standard_gimbal_type_c +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../application;../application/protocol;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;..\module\can_comm;..\module\crc8_crc16;..\module\bmi088;..\module\ist8310;..\module\arm_math\Include;..\module\userlib;..\module\kalman_filter;..\module\oled;..\module\oled;..\module\controller;..\module\controller\stm32;..\support;..\bsp;..\module\remote_control;..\module\dji_motor;..\application;..\module\controller;..\module\dm_motor
  asm include: ..\\Inc;..\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c adc.c can.c crc.c dma.c i2c.c rng.c rtc.c spi.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group module
    ../module/can_comm/: can_comm.c
    ../module/crc8_crc16/: CRC8_CRC16.c
    ../module/bmi088/: BMI088driver.c BMI088Middleware.c
    ../module/ist8310/: ist8310driver.c ist8310driver_middleware.c
    ../module/arm_math/: arm_cortexM4lf_math.lib
    ../module/kalman_filter/: kalman_filter.c QuaternionEKF.c
    ../module/userlib/: user_lib.c
    ../module/oled/: OLED.c
    ../module/controller/: controller.c pid.c PID_control.c
    ../module/controller/stm32/: stm32.c
    ../module/dji_motor/: CAN_receive.c
    ../module/remote_control/: remote_control.c
    ../module/dm_motor/: Mathh.c motor_dm.c
  group applications
    ../application/: chassis_task.c detect_task.c gimbal_behaviour.c gimbal_task.c referee_usart_task.c led_flow_task.c shoot_task.c vision_task.c INS_task.c can_comm_task.c UI_task.c RM_Cilent_UI.c referee.c
  group boards
    ../bsp/: bsp_adc.c bsp_buzzer.c bsp_can.c bsp_crc32.c bsp_delay.c bsp_dwt.c bsp_flash.c bsp_fric.c bsp_i2c.c bsp_imu_pwm.c bsp_laser.c bsp_led.c bsp_PWM.c bsp_rc.c bsp_rng.c bsp_servo_pwm.c bsp_spi.c bsp_usart.c
  group support
    ../support/: fifo.c mem_mang4.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group readme
    ../: README.md
software components: CMSIS:CORE 5.6.0
